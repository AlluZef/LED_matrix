#include "TimeEffect.h"     // Подключаем заголовок класса
#include "utils/MatrixUtils.h" // Утилиты для работы с матрицей

// ============ РЕАЛИЗАЦИЯ МЕТОДОВ КЛАССА TIME_EFFECT ============

// Основной метод обновления (вызывается каждый цикл)
void TimeEffect::update() {
    // Обновляем отображение времени каждую секунду
    if (millis() - lastUpdate >= 1000) {
        lastUpdate = millis(); // Запоминаем время обновления
        
        drawTime();    // Перерисовываем время
        FastLED.show(); // Обновляем матрицу
    }
}

// Установка цвета отображения времени
void TimeEffect::setHue(int hue) {
    timeHue = constrain(hue, 0, 255);
}

// Установка яркости отображения времени
void TimeEffect::setBrightness(int brightness) {
    timeBrightness = constrain(brightness, 0, 255);
}

// ============ ПРИВАТНЫЕ МЕТОДЫ ============

// Установка пикселя в системе координат (0,0 - левый нижний угол)
void TimeEffect::setPixelLB(int x, int y, CRGB color) {
    // x: 0-15 слева направо
    // y: 0-15 снизу вверх
    
    // Проверяем границы координат
    if (x >= 0 && x < MATRIX_WIDTH && y >= 0 && y < MATRIX_HEIGHT) {
        // Преобразуем координаты: инвертируем Y, так как в матрице
        // координата Y=0 обычно находится сверху
        int transformedY = MATRIX_HEIGHT - 1 - y;
        
        // Устанавливаем пиксель через утилиту
        leds[getPixelIndex(x, transformedY)] = color;
    }
}

// Отрисовка цифры размером 3x7 пикселей
void TimeEffect::drawDigit3x7(int startX, int startY, int digit, CRGB color) {
    // startX, startY - координаты левого нижнего угла цифры
    // digit - цифра от 0 до 9
    // color - цвет цифры
    
    // Массив шаблонов для цифр 0-9 (7 строк по 3 пикселя)
    // 1 означает "зажечь пиксель", 0 - "не зажигать"
    const bool digitPixels[10][7][3] = {
        // 0
        {{0,1,0}, {1,0,1}, {1,0,1}, {1,0,1}, {1,0,1}, {1,0,1}, {0,1,0}},
        // 1
        {{0,1,0}, {1,1,0}, {0,1,0}, {0,1,0}, {0,1,0}, {0,1,0}, {1,1,1}},
        // 2
        {{0,1,0}, {1,0,1}, {0,0,1}, {0,1,0}, {1,0,0}, {1,0,0}, {1,1,1}},
        // 3
        {{0,1,0}, {1,0,1}, {0,0,1}, {0,1,0}, {0,0,1}, {1,0,1}, {0,1,0}},
        // 4
        {{1,0,1}, {1,0,1}, {1,0,1}, {1,1,1}, {0,0,1}, {0,0,1}, {0,0,1}},
        // 5
        {{1,1,1}, {1,0,0}, {1,1,0}, {0,0,1}, {0,0,1}, {1,0,1}, {0,1,0}},
        // 6
        {{0,1,0}, {1,0,1}, {1,0,0}, {1,1,0}, {1,0,1}, {1,0,1}, {0,1,0}},
        // 7
        {{1,1,1}, {0,0,1}, {0,0,1}, {0,1,0}, {0,1,0}, {0,1,0}, {0,1,0}},
        // 8
        {{0,1,0}, {1,0,1}, {1,0,1}, {0,1,0}, {1,0,1}, {1,0,1}, {0,1,0}},
        // 9
        {{0,1,0}, {1,0,1}, {1,0,1}, {0,1,1}, {0,0,1}, {1,0,1}, {0,1,0}}
    };
    
    // Проверяем, что цифра в допустимом диапазоне
    if (digit < 0 || digit > 9) return;
    
    // Рисуем пиксели цифры согласно шаблону
    for (int row = 0; row < 7; row++) {
        for (int col = 0; col < 3; col++) {
            // Если в шаблоне стоит 1 - зажигаем пиксель
            if (digitPixels[digit][row][col]) {
                int pixelX = startX + col;
                int pixelY = startY + row;
                setPixelLB(pixelX, pixelY, color);
            }
        }
    }
}

// Основная функция отрисовки времени
void TimeEffect::drawTime() {
    // Очищаем матрицу перед отрисовкой нового времени
    FastLED.clear();
    
    // Получаем текущее время
    int hours = hour();
    int minutes = minute();
    
    // Проверяем, установлено ли время
    if (hours == 0 && minutes == 0 && year() < 2020) {
        // Время не установлено (год меньше 2020)
        return;
    }
    
    // Создаем цвет для отображения времени с учетом настроенной яркости
    CRGB timeColor = CHSV(timeHue, 255, timeBrightness);
    
    // ===== ОТРИСОВКА ЧАСОВ (левый верхний угол) =====
    int hourTens = hours / 10;   // Десятки часов (например, для 14: 1)
    int hourOnes = hours % 10;   // Единицы часов (например, для 14: 4)
    
    // Координаты для часов (левый верхний угол)
    // startX = 1 (отступ от левого края на 1 пиксель)
    // startY = 1 (отступ от верха на 1 пиксель, но помним что Y растет вверх)
    int hoursStartX = 1;
    int hoursStartY = 1;
    
    // Рисуем десятки и единицы часов с отступом в 1 пиксель между цифрами
    drawDigit3x7(hoursStartX, hoursStartY, hourTens, timeColor);
    drawDigit3x7(hoursStartX + 4, hoursStartY, hourOnes, timeColor);
    
    // ===== ОТРИСОВКА МИНУТ (правый нижний угол) =====
    int minuteTens = minutes / 10;  // Десятки минут
    int minuteOnes = minutes % 10;  // Единицы минут
    
    // Координаты для минут (правый нижний угол)
    // Две цифры занимают 7 пикселей (3+1+3)
    // startX = 16 - 7 - 1 = 8 (отступ от правого края на 1 пиксель)
    // startY = 8 (отступ от низа, цифры будут в нижней части матрицы)
    int minutesStartX = 8;
    int minutesStartY = 8;
    
    // Рисуем десятки и единицы минут
    drawDigit3x7(minutesStartX, minutesStartY, minuteTens, timeColor);
    drawDigit3x7(minutesStartX + 4, minutesStartY, minuteOnes, timeColor);
}